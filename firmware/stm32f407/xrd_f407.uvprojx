# Keil uVision project xrd_f407.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: a +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx
  c include: App;Device\Include
  asm define: STM32F407xx
  asm include: App;Device\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group ..\App
    ./App/: bsp_clock.c bsp_imu.c bsp_led.c bsp_lift.c bsp_motor.c bsp_systick.c bsp_uart.c main.c odom.c proto.c
  group Device
    ./Device/Src/: startup_stm32f407xx.s system_stm32f4xx.c
software components: CMSIS:CORE 5.3.0, Device:CubeMX 1.0.0
